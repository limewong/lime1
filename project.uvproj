# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\OS;.\Lib;.\Driver
  group OS
    ./OS/: Conf_tny.A51
  group User
    ./User/: main.c
  group Lib
    ./Lib/: Delay.c GPIO.c NVIC.c UART.c UART_Isr.c ADC.c ADC_Isr.c STC8H_PWM.c
  group Driver
    ./Driver/: Light.c Key.c Battery.c Buzzer.c Ultrasonic.c Motors.h Motors.c
